# Keil uVision project com.uvprojx, settings and files
target com (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: com +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;            ../Drivers/STM32F1xx_HAL_Driver/Inc;            ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;            ../Drivers/CMSIS/Include;            ..\User\font;            ..\User\ili9341_lcd;            ..\User\xpt2046_touch;            ..\User\BT04_E;            ..\User\fatfs;            ..\User\font;            ..\User\mfrc522;            ..\User\sz_system;            ..\User\uln2003;            ..\User\w25q64_flash;            ..\User\zw101_finger;            ..\User\0_for_whole_project;            ..\User\freeRTOS\include;            ..\User\freeRTOS\ports\RVDS\ARM_CM3;            ..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../User/font/: fonts.c
    ../User/ili9341_lcd/: ili9341.c
    ../User/xpt2046_touch/: xpt2046.c
    ../User/BT04_E/: bt04_e.c
    ../User/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
    ../User/mfrc522/: mfrc522.c
    ../User/sz_system/: sz_system.c
    ../User/uln2003/: uln2003.c
    ../User/w25q64_flash/: w25q64.c
    ../User/zw101_finger/: zw101.c
    ../User/0_for_whole_project/: for_whole_project.c project_task.c button_keyboard.c
    ../Src/: main.c gpio.c fsmc.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_sram.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group FreeRTOS
    ../User/freeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../User/freeRTOS/ports/MemMang/: heap_4.c
    ../User/freeRTOS/ports/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
